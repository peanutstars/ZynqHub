SRC_URI += "file://user_2018-09-18-22-16-00.cfg \
            file://user_2018-09-28-22-10-00.cfg \
            file://user_2019-03-11-22-09-00.cfg \
            file://user_2019-03-11-22-29-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

